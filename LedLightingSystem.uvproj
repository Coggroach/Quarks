# Keil uVision project LedLightingSystem.uvproj, settings and files
target Internal Flash (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: LPC2468 NXP (founded by Philips)
  cpu: IRAM(0x40000000-0x4000FFFF) IRAM2(0x7FE00000-0x7FE03FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: LedLightingSystem
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: ARM7_LPC2468_TCD
  c include: .;..\FreeRTOS\Source\portable\TCD\ARM7_LPC2468;..\FreeRTOS\Source\include;.\LCD
  asm include: ..\FreeRTOS\Source\portable\TCD\ARM7_LPC2468
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x40000000 size 0x10000
  memory RVCT10: RAM 0x7fe00000 size 0x4000
  group Startup Code
    ./: LPC2400.s
  group Application Code
    ./: main.c console.c Retarget.c serial.c console.h serial.h serialISR.s lcdISR.s
  group FreeRTOS
    ../FreeRTOS/Source/: list.c queue.c tasks.c
    ../FreeRTOS/Source/portable/TCD/ARM7_LPC2468/: port.c portASM.s portmacro.h portmacro.inc
    ../FreeRTOS/Source/portable/MemMang/: heap_3.c
    ./: FreeRTOSConfig.h
  group LCD
    ./LCD/: font5x7.c lcd_grph.c lcd_hw.c config.h font_macro.h font5x7.h general.h lcd_grph.h lcd_hw.h
  group Graphics
    ./Control/: Colour.h Components.c Components.h Graphics.c Graphics.h Shapes.c Shapes.h LEDLights.c LEDLights.h LCDGraphics.c LCDGraphics.h LCDControl.c IDManager.c IDManager.h LCDControl.h Messages.h BoardButtons.c BoardButtons.h I2C.h Verbose.h
